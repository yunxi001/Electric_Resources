#include<stdio.h>
int main()
{
	int i,j,n;
	int a[2][5]={{1,4,8,7,5},{2,5,6,9,3}};
	for(i=0;i<=4;i++)
	if(a[0][i]>a[0][i+1])
	{
		n=a[0][i];
		a[0][i]=a[0][i+1];
		a[0][i+1]=n;
	}
	if(a[0][4]<a[1][4])
	printf("%d",a[0][4]);
	
	int a[2][5]={{1,4,8,7,5},{2,5,6,9,3}};
	for(i=0;i<=4;i++)
	if(a[1][i]>a[0][i+1])
	{
		n=a[1][i];
		a[1][i]=a[1][i+1];
		a[1][i+1]=n;
	}
	if(a[0][4]>a[1][4])
	printf("%d",a[1][4]);
	return 0;
}
